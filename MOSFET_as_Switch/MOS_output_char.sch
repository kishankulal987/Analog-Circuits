** sch_path: MOSFET_as_Switch/MOS_output_char.sch
**.subckt MOS_output_char
XM2 VDS VGS GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1 + 2)/2) * 20 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29 / 20 ' nrs='0.29 / 20 '
+ sa=0 sb=0 sd=0 mult=1 m=1
VDS VDS GND 1.8
[expr {falsename=V2 ? "VGS VGS GND 1.8
.save i(vgs)
.save :(:)
.save "vgsvgsgnd("vgsvgsgnd)
.save 1.8(1.8)
.save "}]("}])
**** begin user architecture code

.lib /usr/local/share/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.dc VDS 0 1.8 0.01
.save all


**** end user architecture code
**.ends
.GLOBAL GND
.end
